# Copyright 2022, Technology Innovation Institute
#
# SPDX-License-Identifier: Apache-2.0

IMAGE_FSTYPES += " \
    ext4.qcow2 \
"
