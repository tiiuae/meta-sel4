FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-HYPR-XXX-Add-seL4-accelerator.patch"

