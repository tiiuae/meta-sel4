FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

CORE_IMAGE_BASE_INSTALL += "mesa mesa-demos"
